# Repository NatsumiAi/AM32-ESC

File README.md:

<!--
 * @Author: BaiLiang
 * @Date: 2026-01-17 11:20:38
 * @LastEditTime: 2026-02-01 10:15:56
 * @Description: 
-->

# AM32 开源电调 (STM32G071 版)

本项目是一款基于 **AM32** 开源固件的高性能无刷电调（ESC）。专为“全国大学生智能汽车竞赛”及高频动力系统设计，采用高集成度方案，支持大电流输出与精准的电流控制。

## 🚀 项目特性

- **核心处理器**: STM32G071GBU6N，ARM Cortex-M0+ 内核，高性能且具有极佳的性价比。
- **驱动芯片**: FD6288Q 三相半桥驱动，成熟稳定。
- **功率 MOSFET**: IRF7480M DirectFET 封装，极低导通内阻（RDSon），散热效率极高。
- **电流检测**: 搭载 **INA240A1** 高侧/线电流检测放大器，提供极高精度的电流反馈，支持精准的电流限幅和力矩控制。
- **电源管理**:
    - **JW5026** Buck 电路将电池电压转换为 8V（驱动电压）。
    - **AP2210K** LDO 提供 3.3V 给 MCU 和逻辑电路。
- **状态指示**: 集成 **WS2812B** RGB 灯珠，可根据电调状态切换颜色。
- **接口**:
    - 标准 SWD 调试接口。
    - 支持 PWM/DShot 信号输入。
    - 支持 UART 异步通信（用于电调配置或遥测）。

## 🛠 硬件规格

| 参数 | 规格 |
| :--- | :--- |
| **输入电压** | 2S - 4S LiPo (根据电容与 Buck 电路限制) |
| **持续电流** | 建议 40A+ (取决于 PCB 散热) |
| **固件** | AM32 (Multi-Protocol BLDC) |
| **PCB 层数** | 2/4 层 (建议使用 2oz 铜厚) |
| **设计软件** | KiCad 9.0.7 |

## 📂 硬件连接定义 (引脚映射)

根据原理图设计，关键引脚定义如下（编译 AM32 固件时需参考）：

- **PWM 输入 (Signal)**: `PA2` (ESC_S1)
- **电感/相电压感测**: `PA3 (SENCE_O_1)`, `PD1 (SENCE_B_1)`, `PB7 (SENCE_A_1)`
- **电流检测 (Current)**: `PA4 (ADC_CUR)`
- **电压检测 (V-Bat)**: `PA1 (ADC_BAT)`
- **驱动控制 (Gate Drivers)**:
    - Phase A: `PA10 (H)`, `PB15 (L)`
    - Phase B: `PA9 (H)`, `PB14 (L)`
    - Phase C: `PA8 (H)`, `PB13 (L)`
- **RGB LED**: `PB8 (WS2812)`

## 💾 固件烧录与配置

本项目运行 **AM32** 开源固件。

1.  **固件源码/下载**:
    - AM32 官方 GitHub: [https://github.com/am32-esc/AM32](https://github.com/am32-esc/AM32)
    - 预编译固件下载: [AM32 Releases](https://github.com/am32-esc/AM32/releases)
2.  **配置工具**:
    - 建议使用官方在线配置器: [https://configurator.am32.ca/](https://configurator.am32.ca/)
3.  **烧录方式**:
    - 初次烧录：通过 ST-Link 连接板载 SWD 接口，使用 `STM32CubeProgrammer` 烧录 Bootloader。
    - 后续升级：可通过信号线进行串口升级。

## ⚠️ 免责声明

- 本项目为开源硬件，DIY 存在风险。在焊接和通电测试前，请务必检查电路是否存在短路。
- 建议初次通电时使用限流电源，以防止 MOSFET 烧毁。
- 作者不对使用本设计造成的任何直接或间接损失负责。

## 📜 许可协议

本项目硬件方案基于 [CERN Open Hardware Licence](https://ohwr.org/project/cernohl/wikis/Documents/CERN-OHL-version-2) 或 MIT 协议开源。固件部分遵循 AM32 原作者的 GPL v3 协议。

---
**设计者**: 柏亮 (Bailiang)
**所属单位**: 全国大学生41届智能汽车竞赛国防科技大学

## KiCad design AM32电调.kicad_pcb

Parts:
C1, C2, C4, C12, C17: 100n; C_0402_1005Metric
C3: 4.7u; C_0402_1005Metric
C5: 100n(50v); C_0402_1005Metric
C6: 4.7u(50v); C_0603_1608Metric
C7: 10u(16v); C_0603_1608Metric
C8: 1u(25v); C_0402_1005Metric
C9: 2.2u; C_0402_1005Metric
C10: 100p; C_0402_1005Metric
C11: 1n; C_0402_1005Metric
C13: 4.7u(16v); C_0402_1005Metric
C14, C15, C16: 1u; C_0603_1608Metric
C18, C19, C20, C21, C22, C23: 10u; C_1206_3216Metric
D1: WS2812B-2020; LED_WS2812B-2020_PLCC4_2.0x2.0mm
D2: SMF8.0A; D_SOD-123F_TVS
D3: SMBJ30CA; D_SMB
D4, D5, D6: SD103AX; D_SOD-523
L1: 6.8u; L_0805_2012Metric
Q1, Q2, Q3, Q4, Q5, Q6: IRF7480M; DirectFET_ME
R1, R3, R7, R8, R9, R19, R20, R22, R23, R26, R27: 10k; R_0402_1005Metric
R2: 100k; R_0402_1005Metric
R4: 90.9k; R_0402_1005Metric
R5: 1m; R_2512_6332Metric
R6: 56; R_0402_1005Metric
R10, R11, R12, R16: 47k; R_0402_1005Metric
R13, R14, R15, R17: 4.7k; R_0402_1005Metric
R18, R21, R24, R25, R28, R29: 10; R_0402_1005Metric
R30, R31: 100; R_0402_1005Metric
U1: STM32G071GBUxN; QFN-28_4x4mm_P0.5mm
U2: SOT-23-6_L2.9-W1.6-P0.95-LS2.8-BR; Manufacturer Part JW5026; LCSC Part Name 40V/1A 1.1MHz 同步降压转换器
U3: AP2210K-3.3TRG1; SOT-23-5
U5: QFN-24_L4.0-W4.0-P0.50-BL-EP2.6; Manufacturer Part FD6288Q; LCSC Part Name 三相250V栅极驱动器
U6, U7: CONN-SMD_4P-P1.00_MEGASTAR_ZX-SH1.0-4PWT; Manufacturer Part ZX-SH1.0-4PWT; LCSC Part Name 1x4P 间距:1mm 卧贴 系列:SH
U8: INA240A1PW; TSSOP-8_4.4x3mm_P0.65mm

Connections:
+3.3V: C2.1, C3.1, C9.2, C12.2, D1.4 (VDD), U1.3 (VDD), U3.5 (OUT), U6.4, U6.5, U8.5 (V+)
+8V: C7.1, C8.2, C13.2, D2.1 (K), D4.2 (A), D5.2 (A), D6.2 (A), L1.2, R4.2, U3.1 (IN), U3.3 (EN), U5.4 (VCC)
ADC_BAT: C17.2, R16.1, R17.1, U1.12 (PA6)
ADC_CUR: R6.2, U1.10 (PA4), U7.4, U7.5
ESC_S1: R31.1, U1.24 (PD2)
FB: R3.2, R4.1, U2.3 (FB)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C12.1, C13.1, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, D1.2 (VSS), D2.2 (A), D3.1 (K), Q2.3 (S), Q4.3 (S), Q6.3 (S), R1.2, R3.1, R13.1, R14.1, R15.1, R17.2, R20.1, R23.1, R27.1, U1.4 (VSS), U2.2 (GND), U3.2, U5.6 (COM), U5.25 (EP), U6.1, U6.6, U7.1, U7.6, U8.1 (GND), U8.4 (GND), U8.6 (REF2), U8.7 (REF1)
MOS_AH_1: R18.1, R19.2, U5.19 (HO1)
MOS_AL_1: R20.2, R21.1, U5.11 (LO1)
MOS_BH_1: R22.2, R24.1, U5.16 (HO2)
MOS_BL_1: R23.2, R25.1, U5.10 (LO2)
MOS_CH_1: R26.2, R28.1, U5.13 (HO3)
MOS_CL_1: R27.2, R29.1, U5.9 (LO3)
MOTOR_A_1: C14.2, Q1.3 (S), Q2.1 (D), R10.2, R19.1, U5.18 (VS1)
MOTOR_B_1: C15.2, Q3.3 (S), Q4.1 (D), R11.2, R22.1, U5.15 (VS2)
MOTOR_C_1: C16.2, Q5.3 (S), Q6.1 (D), R12.2, R26.1, U5.12 (VS3)
NRST: C1.1, U1.5 (PF2)
unnamed: Q1.2 (G), R18.2
unnamed: Q2.2 (G), R21.2
unnamed: Q3.2 (G), R24.2
unnamed: Q4.2 (G), R25.2
unnamed: Q5.2 (G), R28.2
unnamed: Q6.2 (G), R29.2
unnamed: R6.1, U8.8
unnamed: R30.2, U7.3
unnamed: R31.2, U7.2
unnamed: C4.1, U2.1 (BST)
unnamed: R2.1, U2.4 (EN)
unnamed: C4.2, L1.1, U2.6 (SW)
unnamed: C10.2, U3.4 (BYP)
PWM_AH_1: U1.19 (PA10/PA12), U5.22 (HIN1)
PWM_AL_1: U1.15 (PB15), U5.1 (LIN1)
PWM_BH_1: U1.18 (PA9/PA11), U5.23 (HIN2)
PWM_BL_1: U1.14 (PB0), U5.2 (LIN2)
PWM_CH_1: U1.16 (PA8), U5.24 (HIN3)
PWM_CL_1: U1.13 (PA7), U5.3 (LIN3)
SENCE_A_1: R7.2, R10.1, R15.2, U1.27 (PB7)
SENCE_B_1: R8.2, R11.1, R14.2, U1.23 (PD1)
SENCE_C_1: R9.2, R12.1, R13.2, U1.8 (PA2)
SENCE_O_1: R7.1, R8.1, R9.1, U1.9 (PA3)
SWCLK: R1.1, U1.21 (SYS_SWCLK), U6.2
SWDIO: U1.20 (SYS_SWDIO), U6.3
URAT_TX: R30.1, U1.26 (PB6)
VBAT: C11.2, D3.2 (A), R5.1, U8.2 (+)
VB_A_1: C14.1, D4.1 (K), U5.20 (VB1)
VB_B_1: C15.1, D5.1 (K), U5.17 (VB2)
VB_C_1: C16.1, D6.1 (K), U5.14 (VB3)
VM: C5.1, C6.1, C11.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, Q1.1 (D), Q3.1 (D), Q5.1 (D), R2.2, R5.2, R16.2, U2.5 (VIN), U8.3 (-)
WS2812: D1.3 (DIN), U1.28 (PB8)

Notes on the sheet:
8V to 3v3
MOS驱动
滤波电容
MCU引脚
VBAT to 8V
接口定义
三相全桥逆变电路
高侧电流检测
基于STM32的AM32固件电调
全国大学生41届智能汽车竞赛

Board: 4 copper layers, 22.0 x 39.9 mm, 74 parts (60 on the bottom side), 49 nets.

## Commit log

2026-01-17 init: 原理图
2026-01-17 add: README
2026-02-01 ADD: final draft

Notices in the files:
README.md:
License: GPL v3
